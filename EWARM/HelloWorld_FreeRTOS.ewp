# IAR project HelloWorld_FreeRTOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ..\inc\; ..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\Libraries\CMSIS\Include; ..\Libraries\FreeRTOS\include; ..\Libraries\FreeRTOS\src\portable\IAR\ARM_CM3; ..\Libraries\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc\
  OBJCOPY.OOCOutputFile: Debug.hex
  ILINK.IlinkOutputFile: Debug.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/iar/: startup_stm32f10x_md.s
  group FreeRTOS
    ../Libraries/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../inc/: FreeRTOSConfig.h
    ../Libraries/FreeRTOS/src/portable/MemMang/: heap_2.c
    ../Libraries/FreeRTOS/src/portable/IAR/ARM_CM3/: port.c portasm.s
  group HelloWorld
    ../src/: main.c stm32f1xx_it.c system_stm32f10x.c
  group STM32F10x_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
